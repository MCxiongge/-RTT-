# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WLE5CBUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32WLxx, RT_USING_ARM_LIBC
  c include: applications;.;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;.\libraries\HAL_Drivers;.\libraries\HAL_Drivers\config;.\libraries\STM32WLxx_HAL\CMSIS\Include;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;.\libraries\STM32WLxx_HAL\STM32WLxx_HAL_Driver\Inc;.\libraries\STM32WLxx_HAL\CMSIS\Device\ST\STM32WLxx\Include;modules\SubGHz_Phy;modules\SubGHz_Phy\stm32_radio_driver;modules\SubGHz_Phy\common;rt-thread\components\utilities\ulog
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    ./applications/: main.c
  group CPU
    ./rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Compiler
    ./rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ./rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
  group DeviceDrivers
    ./rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ./rt-thread/components/drivers/misc/: pin.c
    ./rt-thread/components/drivers/rtc/: rtc.c
    ./rt-thread/components/drivers/serial/: serial.c
  group Drivers
    ./board/: board.c
    ./libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_rtc.c drv_usart.c
    ./libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/arm/: startup_stm32wle5xx.s
    ./board/CubeMX_Config/Src/: stm32wlxx_hal_msp.c
  group Finsh
    ./rt-thread/components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ./rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group STM32_HAL
    ./libraries/STM32WLxx_HAL/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_comp.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rng.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_usart.c stm32wlxx_hal_usart_ex.c
    ./libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
  group SubGHz_Phy
    ./modules/SubGHz_Phy/common/: lora-radio-timer.c
    ./modules/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c
    ./modules/SubGHz_Phy/: radio_board_if.c subghz.c subghz_phy_app.c
  group Utilities
    ./rt-thread/components/utilities/ulog/backend/: console_be.c
    ./rt-thread/components/utilities/ulog/: ulog.c
